include nano.inc

SRC_URI[md5sum] = "85db88777dd8b141288989dfeb818c3a"
SRC_URI[sha256sum] = "2cf9726e735f5c962af63d27c2faaead5936e45adec983659fb9e4af88ffa35a"
