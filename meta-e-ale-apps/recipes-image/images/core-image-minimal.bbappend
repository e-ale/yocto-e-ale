CORE_IMAGE_EXTRA_INSTALL += "hello nano"
